# Keil uVision project Template_YZL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template_YZL +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\STM32F4_FWLIB\src;..\STM32F4_FWLIB\inc;..\Main;..\USER\LED;..\Startup_config;..\Common;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\LwIP\include;..\LwIP\include\compat;..\LwIP\include\lwip;..\LwIP\include\netif;..\LwIP\include\lwip\apps;..\LwIP\include\lwip\priv;..\LwIP\include\lwip\prot;..\Main\arch;..\STM32F4x7_ETH_Driver\inc;..\USER\User_Common;..\SYSTEMVIEW_lib;..\USER\BaseDriver
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\Template_YZL.sct
  group Main
    ../Main/: main.c main.h stm32f4xx_it.c stm32f4xx_it.h FreeRTOSConfig.h
  group USER
    ../USER/LED/: led.c led.h
    ../USER/User_Common/: user_delay.c user_delay.h user_Lan8720.c user_Lan8720.h user_tcp_server.c user_tcp_server.h user_ETHCommunication.c user_ETHCommunication.h user_SysType.c user_SysType.h
  group User/BaseDriver
    ../USER/BaseDriver/: user_rcc_config.c user_rcc_config.h user_updata.c user_updata.h user_rtc.c user_rtc.h
  group JlinkRTT
    ../SYSTEMVIEW_lib/: SEGGER_RTT_printf.c SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group Lwip/api
    ../LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/core
    ../LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip/arch
    ../Main/arch/: cc.h ethernetif.c ethernetif.h lwipopts.h perf.h sys_arch.c sys_arch.h
  group Lwip/netif
    ../LwIP/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group Common
    ../Common/: common.c common.h
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c portmacro.h
  group Startup_config
    ../Startup_config/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../STM32F4_FWLIB/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group STM32F4x7_ETH_Driver
    ../STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../STM32F4x7_ETH_Driver/inc/: stm32f4x7_eth.h stm32f4x7_eth_conf.h
